# Keil uVision project stm32_ucosii.uvproj, settings and files
target stm32_ucos (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_ucosii
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\cmsis\CoreSupport;..\cmsis\DeviceSupport\ST\STM32F10x;..\library\inc;..\library\src;..\bsp;..\user;..\os\lib;..\os\config;..\os\core;..\os\ports;..\os\cpu;..\app;..\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group cmsis
    ../cmsis/CoreSupport/: core_cm3.c
    ../cmsis/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group library
    ../library/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group ucosii_config
    ../os/config/: includes.h os_cfg.h
  group ucosii_ports
    ../os/ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucosii_core
    ../os/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group bsp
    ../bsp/: bsp_led.c bsp_systick.c bsp_usart.c bsp.h
  group app
    ../app/: app.h
  group user
    ../user/: stm32f10x_conf.h stm32f10x_it.c main.c
